# Keil uVision project STM32F407_FlightLog.uvprojx, settings and files
target STM32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: VCU_STM32_Log_1_0_0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,VCU_FLIGHT_LOG_ENABLED
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bsp/CAN;../Bsp/CRSF;../App/Inc;../Protocol/Inc
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../Bsp/CAN/: vcu_can_port.c vcu_can_port.h
    ../Bsp/CRSF/: vcu_crsf_port.c vcu_crsf_port.h
  group App
    ../App/Src/: vcu_flight_log.c vcu_app.c vcu_crsf_uart.c vcu_motor_can.c vcu_drive_runtime.c vcu_rc_drive.c vcu_speed_sync.c vcu_target_slew.c vcu_esp_link.c vcu_control_telemetry.c
    ../../common/: vcu_log_wire.c
    ../App/Inc/: vcu_app.h vcu_crsf_uart.h vcu_motor_can.h vcu_motor_config.h vcu_drive_runtime.h vcu_rc_drive.h vcu_speed_sync.h vcu_target_slew.h vcu_esp_link.h vcu_control_telemetry.h
  group Protocol
    ../Protocol/Src/: vcu_can_protocol.c vcu_crsf.c mx_can_protocol.c vcu_gateway_protocol.c
    ../Protocol/Inc/: vcu_can_protocol.h vcu_crsf.h mx_can_protocol.h vcu_gateway_protocol.h
software components: CMSIS:CORE 6.2.0
